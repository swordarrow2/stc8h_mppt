# Keil uVision project stc_mppt.uvproj, settings and files
target stc_mppt (MCS-51)
  device: AI8H8K64U Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: stc_mppt +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Sources\inc
  group AiCube
    ./Sources/: main.c
  group devices
    ./Sources/device/: battery.c pd.c solar.c
  group drivers
    ./Sources/driver/: ssd1306.c adc.c ch224.c clock.c i2c.c iap.c mathlib.c port.c pwm.c rtc.c timer.c uart.c usblib.c oled.c eg2104.c
    ./Sources/lib/: stc_usb_cdc_8h_xdata_bl51.lib stc8_mdu16.lib
